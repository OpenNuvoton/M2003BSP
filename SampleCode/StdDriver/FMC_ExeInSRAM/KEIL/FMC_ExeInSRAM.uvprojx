# Keil uVision project FMC_ExeInSRAM.uvprojx, settings and files
target FMC_ExeInSRAM (6120000::V6.12::.\ARMCLANG)
  device: M2003FC1AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.21
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_ExeInSRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M2003\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\scatter.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2003/Source/: system_M2003.c
    ./: startup_M2003_user.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c fmc.c
